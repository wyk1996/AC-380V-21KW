# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, __RTTHREAD__, AT32F403AVGT7, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: 4G;.;applications;.;charge_pro;.;common;.;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;packages\dlt645-latest\inc;packages\dlt645-latest\port;board;board\inc;..\libraries\f403a_407\rt_drivers;dwin;.;packages\EasyFlash-v4.1.0\inc;..\..\..\components\fal\inc;..\..\..\components\fal\samples\porting;..\..\..\components\finsh;.;..\..\..\include;..\libraries\f403a_407\firmware\cmsis\cm4\device_support;..\libraries\f403a_407\firmware\cmsis\cm4\core_support;..\libraries\f403a_407\firmware\drivers\inc;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;packages\rc522-latest;packages\rc522-latest\inc;user_lib;.\packages\w25qxx;.\packages\agile_led-latest\src;.\packages\agile_led-latest\inc;..\libraries\f403a_407\rt_drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/: readme-csh.txt
  group 4G
    4G/: 4GRecv.c ZFFrame.c APFrame.c ModuleA7680C.c YKCFrame.c 4GMain.c HYFrame.c 4GSend.c
  group charge_pro
    charge_pro/: ch_in_io.c chproc.c rn8209.c cp.c chtask.c ch_port.c
  group common
    common/: mq_service.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/ipc/: ringblk_buf.c ringbuffer.c completion.c workqueue.c waitqueue.c pipe.c dataqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c pin.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    ../../../components/drivers/watchdog/: watchdog.c
  group dlt645
    packages/dlt645-latest/src/: dlt645_2007.c dlt645_data.c dlt645_1997.c dlt645.c
    packages/dlt645-latest/port/: dlt645_port.c
    packages/dlt645-latest/sample/: dlt645_sample.c
  group Drivers
    ../libraries/f403a_407/firmware/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    board/src/: at32_msp.c board.c
    ../libraries/f403a_407/rt_drivers/: drv_gpio.c drv_spi.c drv_adc.c drv_rtc.c drv_wdt.c drv_pwm.c drv_flash.c drv_usart.c drv_common.c drv_spi_flash.c drv_hwtimer.c
    ./: hwtimer.c
  group dwin
    dwin/: DispkeyFunction.c DispShowStatus.c MenuDisp .c DwinProtocol.c Dispkey.c dwin_com_pro.c
  group Fal
    ../../../components/fal/src/: fal_flash.c fal_partition.c fal.c fal_rtt.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: device.c kservice.c thread.c timer.c components.c mempool.c mem.c irq.c ipc.c scheduler.c memheap.c object.c clock.c idle.c
  group Libraries
    ../libraries/f403a_407/firmware/drivers/src/: at32f403a_407_exint.c at32f403a_407_emac.c at32f403a_407_rtc.c at32f403a_407_spi.c at32f403a_407_dac.c at32f403a_407_bpr.c at32f403a_407_gpio.c at32f403a_407_sdio.c at32f403a_407_wdt.c at32f403a_407_usart.c at32f403a_407_flash.c at32f403a_407_dma.c at32f403a_407_pwc.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_crm.c at32f403a_407_crc.c at32f403a_407_wwdt.c at32f403a_407_debug.c at32f403a_407_usb.c at32f403a_407_adc.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_tmr.c at32f403a_407_xmc.c
    ../libraries/f403a_407/firmware/cmsis/cm4/device_support/: system_at32f403a_407.c
  group rc522
    packages/rc522-latest/src/: mfrc522.c
    packages/rc522-latest/port/: mfrc522_rtt_stm32_port.c
    ./packages/rc522-latest/examples/: read_nuid.c
  group user_lib
    user_lib/: user_lib.c crc.c timestamp.c
  group w25qxx
    ./packages/w25qxx/: w25qxx.c
  group led
    ./packages/agile_led-latest/src/: led_thread.c agile_led.c
